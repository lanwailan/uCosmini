# Keil uVision project uCOSmini.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: uCOSmini
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\ucos\CPU;.\ucos\Ports;.\ucos\Source
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group ucos/ports
    ./ucos/Ports/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group ucos/source
    ./ucos/Source/: os.h os_cfg.h os_core.c os_task.c os_type.h os_var.c os_time.c
  group ucos/cpu
    ./ucos/CPU/: cpu.h cpu_a.asm
  group app
    ./ucos/: app.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
